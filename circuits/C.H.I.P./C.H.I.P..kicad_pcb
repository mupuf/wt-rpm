# Repository mupuf/wt-rpm

File README:

# Wt-RPM

## Compilation

### Dependencies

#### Ping support

If you are interested in supporting ping, you will have to install liboping.

#### Raspberry Pi backend

To compile the Raspberry Pi backend, please make sure you have installed libwiringPi.

### Compilation

To compile the project, please execute the following steps:

If you plan on using Wt's internal http server:

	CONNECTOR="-DUSE_CON_HTTP=ON"

otherwise

	CONNECTOR="-DUSE_CON_HTTP=OFF"

	mkdir build
	cd build
	cmake .. -DCMAKE_INSTALL_PREFIX=/usr $CONNECTOR

Review the summary, fix as needed. Then do:

	make
	sudo make install

## Configuration

Wt_rpm's configuration must be stored in one of the following location:
  - ./wt-rpm.json
  - ../wt-rpm.json
  - ~/.wt-rpm.json
  - /etc/wt-rpm.json

The file must follow the JSON format and must contain the backend attribute.
At the moment, there are only two acceptable attribute: rasprpm and dummy_rpm.
Here is a sample configuration file:

{
        "backend": "rasprpm",
        "configuration": {
                "computers": [
                        {
                                "name": "pc1",
                                "ip_address": "192.168.0.42",
                                "read_acl": ["all"],
                                "write_acl": [],

                                "power_led_gpio": {
                                        "pin": 6,
                                        "inverted": "true"
                                },

                                "power_switch_gpio": {
                                        "pin": 8,
                                        "inverted": "false"
                                },

                                "atx_switch_gpio": {
                                        "pin": 10,
                                        "inverted": "false"
                                }
                        },

                        {
                                "name": "pc2",
                                "ip_address": "192.168.0.43",
                                "read_acl": ["toto", "john"],
                                "write_acl": ["toto"],

                                "power_led_gpio": {
                                        "pin": 1,
                                        "inverted": "true"
                                },

                                "power_switch_gpio": {
                                        "pin": 0,
                                        "inverted": "false"
                                },

                                "atx_switch_gpio": {
                                        "pin": 7,
                                        "inverted": "false"
                                }
                        }
                ]
        }
}

## Authentication

If you want to authenticate users before allowing them to list and control
computers, you will need to use an http server such as nginx. Here is an example:

worker_processes  1;
events {
    worker_connections  1024;
}
http {
    include       mime.types;
    default_type  application/octet-stream;

    keepalive_timeout  65;

    gzip  on;

    server {
        listen       443 ssl;
        server_name  localhost;
        ssl_certificate /etc/nginx/ssl/nginx.crt;
        ssl_certificate_key /etc/nginx/ssl/nginx.key;

         # Wt
        location /resources/ {
            root   /usr/share/Wt/;
            index  index.html index.htm;
        }

        location / {
            root   /usr/share/nginx/html;
            index  index.html index.htm;

            auth_basic "WtRPM";
            auth_basic_user_file /etc/nginx/htpasswd;

            proxy_pass http://127.0.0.1:9090/;
        }
    }
}

Don't forget to use SSL otherwise, the passwords will be sent through the network
in plain text!

## Post-Install

After installing Wt-RPM, the program needs some special capabilities to run as
a normal user. Please run the following:

setcap "CAP_NET_RAW=+ep CAP_SYS_RAWIO=+ep" /usr/bin/wt_rpm

Please also make sure that the user has the right to write to /dev/mem.

### Systemd

If you are able to execute wt_rpm properly, you can use the shipped systemd
unit (configured for the user wtrpm).

## KiCad design circuits/C.H.I.P./C.H.I.P..kicad_pcb

File circuits/README:

The fzz files are supposed to be oppened by [Fritzing](http://fritzing.org/).

They contain an approximation of the circuit I used and connected to my raspberry pi.

If you have any question, please email me:
Martin Peres <martin.peres <at> labri.fr>

Parts:
J13, J14: DIP-HEADER-2x20; DIP_Header_2x20
P0, P0-1, P1-0, P1-1: CONN_01X03; Pin_Header_Straight_1x03
P2-0, P2-1, P3-0, P3-1, P4-0, P4-1, P5-0, P5-1, P6-0, P6-1, P7-0, P7-1, P7-CHG1: CONN_01X02; Pin_Header_Straight_1x02
Q0, Q1: SOT-23_Handsoldering
Q2, Q3, Q4, Q5, Q6, Q7: MOSFET-NCHANNELSMD; SOT-23_Handsoldering
R0, R1, R2, R3, R4, R5, R6, R7, R10-1, R11-1: 10k; R_0805_HandSoldering

Connections:
+1.8V: J13.7
+3.3V: J13.5, J14.9, R0.2, R1.1
+5V: J13.3, J14.2
/AP-EINT1: J14.23
/AP-EINT3: J14.24
/CSICK: J14.28
/CSID0: J14.31
/CSID1: J14.32
/CSID2: J14.33
/CSID3: J14.34
/CSID4: J14.35
/CSID5: J14.36
/CSID6: J14.37
/CSID7: J14.38
/CSIHSYNC: J14.29
/CSIPCK: J14.27
/CSIVSYNC: J14.30
/FEL: J14.7
/HPCOM: J14.6
/HPL: J14.4
/HPR: J14.8
/LCD-CLK: J13.35
/LCD-D2: J13.17
/LCD-D3: J13.20
/LCD-D4: J13.19
/LCD-D5: J13.22
/LCD-D6: J13.21
/LCD-D7: J13.24
/LCD-D10: J13.23
/LCD-D11: J13.26
/LCD-D12: J13.25
/LCD-D13: J13.28
/LCD-D14: J13.27
/LCD-D15: J13.30
/LCD-D18: J13.29
/LCD-D19: J13.32
/LCD-D20: J13.31
/LCD-D21: J13.34
/LCD-D22: J13.33
/LCD-D23: J13.36
/LCD-DE: J13.40
/LCD-HSYNC: J13.38
/LCD-VSYNC: J13.37
/LRADC: J14.11
/MICIN1: J14.12
/MICM: J14.10
/PWM0: J13.18
/PWRON: J13.10
/TS: J13.6
/TWI1-SCK: J13.11
/TWI1-SDA: J13.9
/TWI2-SCK: J14.26
/TWI2-SDA: J14.25
/UART1-RX: J14.5
/UART1-TX: J14.3
/X1: J13.13
/X2: J13.14
/XIO-P0: J14.13, Q0.3 (D), R1.2
/XIO-P1: J14.14, Q1.3 (D), R0.1
/XIO-P2: J14.15, Q2.1 (G), R2.1
/XIO-P3: J14.16, Q3.1 (G), R3.1
/XIO-P4: J14.17, Q4.1 (G), R4.1
/XIO-P5: J14.18, Q5.1 (G), R5.1
/XIO-P6: J14.19, Q6.1 (G), R6.1
/XIO-P7: J14.20, Q7.1 (G), R7.1
/Y1: J13.15
/Y2: J13.16
GND: J13.1, J13.4, J13.12, J13.39, J14.1, J14.21, J14.22, J14.39, J14.40, P7-CHG1.1, Q0.2 (S), Q1.2 (S), R2.2, R3.2, R4.2, R5.2, R6.2, R7.2
unnamed: P0.1, P0-1.1, Q0.1 (G), R10-1.2
unnamed: P0.2, P0-1.2
unnamed: P0.3, P0-1.3, R10-1.1
unnamed: P1-0.1, P1-1.1, Q1.1 (G), R11-1.2
unnamed: P1-0.2, P1-1.2
unnamed: P1-0.3, P1-1.3, R11-1.1
unnamed: P2-0.1, P2-1.1, Q2.2 (S)
unnamed: P2-0.2, P2-1.2, Q2.3 (D)
unnamed: P3-0.1, P3-1.1, Q3.2 (S)
unnamed: P3-0.2, P3-1.2, Q3.3 (D)
unnamed: P4-0.1, P4-1.1, Q4.2 (S)
unnamed: P4-0.2, P4-1.2, Q4.3 (D)
unnamed: P5-0.1, P5-1.1, Q5.2 (S)
unnamed: P5-0.2, P5-1.2, Q5.3 (D)
unnamed: P6-0.1, P6-1.1, Q6.2 (S)
unnamed: P6-0.2, P6-1.2, Q6.3 (D)
unnamed: P7-0.1, P7-1.1, Q7.2 (S)
unnamed: P7-0.2, P7-1.2, Q7.3 (D)
VBAT: J13.8
VCHG: J13.2, P7-CHG1.2

Board: 2 copper layers, 40.6 x 55.2 mm, 39 parts (18 on the bottom side), 30 nets.

Other parts of the board:
SCRATCH0, SCRATCH1: Pin_Header_Straight_2x08_Pitch2.54mm

## KiCad design circuits/kikad/rasp_side.kicad_pcb

Board: 2 copper layers, 99.7 x 99.7 mm, 46 parts (0 on the bottom side), 62 nets.

Parts:
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10: RJ45; RJ45_8
OC1, OC2, OC3, OC4, OC5, OC6, OC7, OC8, OC9, OC10, OC11, OC12, OC13, OC14, OC15: 6N138; DIP-8__300
R1, R5, R9, R13, R17: 4k; R4
R2, R6, R10, R14, R18: 10k; R4
R3, R4, R7, R8, R11, R12, R15, R16, R19, R20: 1.2k; R4
Rasp Pi: pin_array_13x2

Connections:
+3.3V: OC3.8, OC6.8, OC9.8, OC12.8, OC15.8, R2.2, R6.2, R10.2, R14.2, R18.2, Rasp Pi.1, Rasp Pi.17
GND: OC1.3, OC2.3, OC3.5, OC4.3, OC5.3, OC6.5, OC7.3, OC8.3, OC9.5, OC10.3, OC11.3, OC12.5, OC13.3, OC14.3, OC15.5, Rasp Pi.6
unnamed: J5.3, R17.2
unnamed: J5.7, OC13.6, OC13.8
unnamed: J5.6, OC14.5
unnamed: J5.5, OC14.6, OC14.8
unnamed: J5.4, OC15.2
unnamed: OC15.3, R17.1
unnamed: OC14.2, R19.2
unnamed: J5.8, OC13.5
unnamed: OC15.6, R18.1, Rasp Pi.23
unnamed: OC13.2, R20.2
unnamed: R20.1, Rasp Pi.19
unnamed: R19.1, Rasp Pi.21
unnamed: OC12.6, R14.1, Rasp Pi.22
unnamed: OC10.2, R16.2
unnamed: OC11.2, R15.2
unnamed: R16.1, Rasp Pi.26
unnamed: R15.1, Rasp Pi.24
unnamed: J4.7, OC10.6, OC10.8
unnamed: J4.6, OC11.5
unnamed: J4.5, OC11.6, OC11.8
unnamed: J4.3, R13.2
unnamed: J4.4, OC12.2
unnamed: OC12.3, R13.1
unnamed: J3.7, OC7.6, OC7.8
unnamed: R3.1, Rasp Pi.13
unnamed: OC3.3, R1.1
unnamed: J1.6, OC2.5
unnamed: J1.5, OC2.6, OC2.8
unnamed: J1.4, OC3.2
unnamed: J1.3, R1.2
unnamed: OC3.6, R2.1, Rasp Pi.15
unnamed: J1.7, OC1.6, OC1.8
unnamed: J1.8, OC1.5
unnamed: OC6.6, R6.1, Rasp Pi.7
unnamed: OC6.3, R5.1
unnamed: J2.3, R5.2
unnamed: R8.1, Rasp Pi.3
unnamed: OC4.2, R8.2
unnamed: R7.1, Rasp Pi.5
unnamed: OC1.2, R4.2
unnamed: OC2.2, R3.2
unnamed: R4.1, Rasp Pi.11
unnamed: OC5.2, R7.2
unnamed: J2.6, OC5.5
unnamed: J2.5, OC5.6, OC5.8
unnamed: J2.4, OC6.2
unnamed: J2.8, OC4.5
unnamed: J3.3, R9.2
unnamed: J3.8, OC7.5
unnamed: J4.8, OC10.5
unnamed: OC9.3, R9.1
unnamed: OC9.6, R10.1, Rasp Pi.8
unnamed: OC7.2, R12.2
unnamed: OC8.2, R11.2
unnamed: R12.1, Rasp Pi.12
unnamed: R11.1, Rasp Pi.10
unnamed: J3.5, OC8.6, OC8.8
unnamed: J3.6, OC8.5
unnamed: J3.4, OC9.2
unnamed: J2.7, OC4.6, OC4.8

## Commit log

2013-03-23 disable adding multiple computers with the same name
2013-03-23 various clean ups
2013-03-23 fix the general layout + add a configuration parser
    This commit makes the AbstractRPM run as a single instance accross all views.
    There may be some locking issues that I'll have to fix but it seems to run
    fine right now.
    This commit also introduces the beginning of configuration parsing
2013-03-23 Parse the configuration of RaspRPM
2013-03-23 add better log support
2013-03-23 add some nice logging capabilities
2013-03-23 fix the style
2013-03-23 silent a warning
2013-03-24 change the name of the binary
2013-03-24 fix getExeDirectory() when running with some added capabilities
2013-03-24 add ping support
2013-03-24 fixing logs + occasional segfaults
2013-03-24 prefer slightly leaking than potential crashes
2013-03-25 rasp_rpm: add 2 threads to poll both the pings and the GPIOs
2013-03-25 do not rely on the view pointer in abstract RPM to be valid
    Simply send the pointer to WServer::post and let it manage this by himself.
    We may need to bind the functions too (using WApplication::bind) but the
    chat example doesn't make use of it :s
2013-03-25 Start optimizing to get a lower memory footprint and lower bandwidth occupation
2013-04-04 stop leaking ressources!
2013-04-11 add the GPIO backend to the rasprpm backend
2013-04-21 add the fritzing files
2013-04-29 update the circuits
2013-05-02 fix the configuration's parsing for rasprpm
2013-05-02 add some install-related documentations and systemd unit!
2013-10-14 update the state of the power LED on startup
2014-05-21 Add an initial version of the kicad files
2014-05-24 improved version of the kicad circuit
2014-05-24 update the circuit a little
2014-06-10 kicad: add holes in the circuit
2014-06-11 kicad: style fixes
2014-07-18 backend: add a dummy backend
2014-08-02 cmake: look for wiringpi at the right place
2014-08-02 RPM: show the auth name when available
2014-08-03 rpm: move configuration parsing to the abstractRPM
2014-08-03 rpm: put the polling threads and the events implementation in AbstractRPM
2014-08-03 rpm: add ACLs on computers
2014-08-03 computerview: do not allow the user to click on a button if the user has no write access
2014-08-03 computerview: port boost::signal to boost::signals2
2014-08-03 conf: make the configuration backend-agnostic
2014-08-03 doc: update the documentation to explain how to use authentication
2017-02-06 circuits: add a new circuit for Wt-RPM
2017-02-06 update the C.H.I.P. design and add the gerbers
2018-01-28 chip-backend: initial import
2018-01-29 HACK

Notices in the files:
circuits/C.H.I.P./C.H.I.P..kicad_pcb:
Released under the CERN Open Hardware License v1.2
